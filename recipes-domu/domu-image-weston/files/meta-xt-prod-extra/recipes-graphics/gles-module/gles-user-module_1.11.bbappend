require gles-user-module.inc

BRANCH = "1.11/5516664"
SRCREV = "${AUTOREV}"
PREFERRED_VERSION_llvmpvr = "7.0.1"
#EXCLUDED_APIS = "opencl vulkan"
